# Keil uVision project LCD.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL,ARM_MATH_CM3
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\HARDWARE\LCD;..\HARDWARE\STM32F10x_StdPeriph_Driver;..\HARDWARE\STM32F10x_StdPeriph_Driver\inc;..\HARDWARE\ADC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/ADC/: adc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_dma.c
  group README
    ../: README.TXT
software components: CMSIS:DSP 1.4.6
